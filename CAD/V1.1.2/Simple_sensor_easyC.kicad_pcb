# Repository SolderedElectronics/Simple-fire-sensor-board-with-easyC-hardware-design

File README.md:

# Simple fire sensor board with easyC Hardware design

## About the product

|  |
| :----------------------------------------------------------: |
|      [Buy Simple fire sensor board with easyC](https://www.solde.red/333042)      |

On this module there is a component, a phototransistor, which is capable of detecting infrared radiation. Since fire emits a large amount of infrared radiation, this sensor will detect it, but that is not its only application. Wherever there are IR (infra-red) waves, this sensor will detect them, including solar radiation.

The simple sensor comes with easyC connectors onboard, which enables quick and easy connection with the microcontroller.

## Repository contents

All Soldered Electronics hardware designed in KiCAD, and repositories are organized in the following way:

- CAD folder - contains KiCAD files (Schematics, Board, Panel Board), sorted by version. Change log lists all changes between versions.
- OUTPUTS - contains useful files, such as Bill of Materials (BOM), PDF of schematics, 3D .step file of the board and gerber files, sorted by version. 
- OUTPUTS -> Compliance - Certificates and useful legal stuff. 

## Want to contribute?

Please feel free to submit a pull request if you have any contributions. We encourage you to submit an issue or pull request if you find a bug. 

## About Soldered

At Soldered, we design and manufacture a wide selection of electronic products to help you turn your ideas into acts and bring you one step closer to your final project. Our products are intented for makers and crafted in-house by our experienced team in Osijek, Croatia. We believe that sharing is a crucial element for improvement and innovation, and we work hard to stay connected with all our makers regardless of their skill or experience level. Therefore, all our products are open-source. Finally, we always have your back. If you face any problem concerning either your shopping experience or your electronics project, our team will help you deal with it, offering efficient customer service and cost-free technical support anytime. Some of those might be useful for you:

- [Web Store](https://www.soldered.com/shop)
- [Tutorials & Projects](https://soldered.com/learn)
- [Community & Technical support](https://soldered.com/community)

## License info

All Soldered open-source hardware (OSH) is under The TAPR Open Hardware License. Read more in the LICENSE file. 

No warranty - all designs in this repository are distributed in the hope that they will be useful, but without any warranty. They are provided "AS IS", therefore without warranty of any kind, either expressed or implied. The entire quality and performance of what you do with the contents of this repository are your responsibility. In no event, Soldered Electronics will be liable for your damages, losses, including any general, special, incidental or consequential damage arising out of the use or inability to use the contents of this repository. 

## Have fun! 
And thank you from your fellow makers at Soldered Electronics.

## KiCad design CAD/V1.1.2/Simple_sensor_easyC.kicad_pcb

Parts:
C1, C2: 100n; 0603C
D1: purple; 0402LED
FD1: FIDUCIAL; FIDUCIAL_23
H1, H2, H3, H4: HOLE_3.2mm
K1: JST-SH_2pin_1mm_C145954
K2: HEADER_MALE_2X1
K3, K5: easyC-SMD; easyC-connector
K4: HEADER-UPDI
K6: DSHP03TS-S
R1, R3, R4: 10k; 0603R
R2: 2k2; 0402R
U1: ATTINY404-SSNR; SOIC-14

Connections:
3V3: C2.1, K3.3 (3V3), K4.1 (VCC), K5.3 (3V3), R1.2, R3.2, R4.2, U1.1 (VDD)
A0: C1.2, K1.1, K2.2, R1.1, U1.3 (PA5)
ADD1: K6.1, U1.7 (PB2)
ADD2: K6.3, U1.6 (PB3)
ADD3: K6.5, U1.5 (PA7)
D0: R2.1, U1.2 (PA4)
GND: C1.1, C2.2, D1.2 (K), K1.2, K2.1, K3.4 (GND), K3.5 (SHIELD), K4.3 (GND), K5.4 (GND), K5.5 (SHIELD), K6.2, K6.4, K6.6, U1.14 (GND)
unnamed: D1.1 (A), R2.2
SCL: K3.1 (SCL), K5.1 (SCL), R4.1, U1.9 (PB0)
SDA: K3.2 (SDA), K5.2 (SDA), R3.1, U1.8 (PB1)
UPDI: K4.2 (UPDI), U1.10 (UPDI)

Notes on the sheet:
INPUT
ATTINY404 easyC MICROCONTROLLER

Board: 2 copper layers, 22.0 x 38.0 mm, 19 parts (0 on the bottom side), 11 nets.

## Commit log

2022-08-06 Updating open source files.
